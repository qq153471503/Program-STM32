# Keil uVision project MyProgram.uvproj, settings and files
target MyProgarm (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MyProgram +hex
  c flags: Optim=1
  c include: ..\system\delay;..\system\sys;..\system\usart;..\user;..\hardware\74HC595;..\hardware\BH1750;..\hardware\CSB;..\hardware\DJQD;..\hardware\EXIT;..\hardware\HW;..\hardware\INIT;..\hardware\KEY;..\hardware\LED;..\hardware\XJ
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: test.c STM32F10x.s
  group hardware
    ../hardware/74HC595/: 74hc595.c
    ../hardware/BH1750/: bh1750.c
    ../hardware/CSB/: csb.c
    ../hardware/DJQD/: djqd.c
    ../hardware/EXIT/: exit.c
    ../hardware/HW/: hw.c
    ../hardware/INIT/: init.c
    ../hardware/KEY/: key.c
    ../hardware/LED/: led.c
    ../hardware/XJ/: xj.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
