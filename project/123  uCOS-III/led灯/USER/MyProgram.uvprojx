# Keil uVision project MyProgram.uvprojx, settings and files
target MyProgram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCOS-III\UCOS-BSP;..\uCOS-III\UCOS-CONFIG;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\uCOS-III\uCOS-III;..\uCOS-III\uCOS-III\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group hardware
    ../HARDWARE/LED/: led.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group readme
    ../readme/: readme.txt
  group uCOSIII-BSP
    ../uCOS-III/UCOS-BSP/: bsp.c
  group uCOSIII-CPU
    ../uCOS-III/uC-CPU/: cpu_core.c
    ../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uCOSIII-LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOSIII-CORE
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII-PORT
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOSIII-CONFIG
    ../uCOS-III/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
