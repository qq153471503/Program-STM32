# Keil uVision project MyProject.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\servo;..\HARDWARE\KEY;..\HARDWARE\LED;..\SYSTEM\system_rcc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/servo/: servo.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/system_rcc/: system.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group README
    ../readme/: readme.txt
software components: CMSIS:CORE 5.0.0
