# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BH1750;..\HARDWARE\DJQD;..\HARDWARE\INIT;..\HARDWARE\CSB;..\HARDWARE\HW;..\HARDWARE\XJ;..\HARDWARE\74HC595;..\USER;..\HARDWARE\EXIT;..\HARDWARE\CAN;..\HARDWARE\CAN_HOST;..\HARDWARE\FIFO;..\stdperiph_lib\inc;..\CMSIS;..\my_lib;..\stdperiph_lib\inc;..\startup;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\RC522;..\HARDWARE\HMC5883L;..\HARDWARE\BZ;..\HARDWARE\SYN7318;..\HARDWARE\IIC;..\HARDWARE\ZX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ../startup/: stm32f10x_it.c
  group USER
    ./: test.c data_channel.c
  group SYS
    ../SYSTEM/delay/: delay_drv.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/INIT/: init.c
    ../HARDWARE/DJQD/: djqd.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/74HC595/: 74hc595.c
    ../HARDWARE/XJ/: xj.c
    ../HARDWARE/CSB/: csb.c
    ../HARDWARE/HW/: hw.c
    ../HARDWARE/EXIT/: exit.c
    ./: uart_my.c
    ../HARDWARE/CAN/: can_drv.c
    ../HARDWARE/CAN_HOST/: CanP_HostCom.c
    ../HARDWARE/FIFO/: fifo_drv.c
    ../HARDWARE/ADC/: adc.c power_check.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RC522/: RC522.C
    ../HARDWARE/BZ/: bz.c
    ../HARDWARE/SYN7318/: SYN7318.c
    ../HARDWARE/HMC5883L/: hmc5883l.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/ZX/: zx.c
  group stdperiph_lib
    ../stdperiph_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group my_lib
    ../my_lib/: my_lib.c
