# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BH1750;..\HARDWARE\DJQD;..\HARDWARE\INIT;..\HARDWARE\CSB;..\HARDWARE\HW;..\HARDWARE\XJ;..\HARDWARE\74HC595;..\USER;..\HARDWARE\EXIT;..\HARDWARE\CAN;..\HARDWARE\CAN_HOST;..\HARDWARE\FIFO;..\stdperiph_lib\inc;..\CMSIS;..\my_lib;..\stdperiph_lib\inc;..\startup;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\HMC5883L;..\HARDWARE\IIC;..\HARDWARE\SYN7318;..\HARDWARE\ZX;..\HARDWARE\BZ;..\HARDWARE\RC522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ../startup/: stm32f10x_it.c
  group USER
    ./: test.c data_channel.c
  group SYS
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/SYN7318/: SYN7318.c
    ../SYSTEM/delay/: delay_drv.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/INIT/: init.c
    ../HARDWARE/DJQD/: djqd.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/XJ/: xj.c
    ../HARDWARE/CSB/: csb.c
    ../HARDWARE/HW/: hw.c
    ../HARDWARE/EXIT/: exit.c
    ./: uart_my.c
    ../HARDWARE/CAN/: can_drv.c
    ../HARDWARE/CAN_HOST/: CanP_HostCom.c
    ../HARDWARE/FIFO/: fifo_drv.c
    ../HARDWARE/ADC/: adc.c power_check.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ZX/: zx.c
    ../HARDWARE/BZ/: bz.c
    ../HARDWARE/RC522/: RC522.C
  group stdperiph_lib
    ../stdperiph_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group my_lib
    ../my_lib/: my_lib.c
  group readme
    ./: nvic.txt 函数使用说明简介.txt 03词典-用户1.txt
software components: CMSIS:CORE 4.3.0
