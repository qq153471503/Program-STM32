# Keil uVision project 训练1.uvproj, settings and files
target 训练1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 训练1 +hex
  c flags: Optim=1
  c include: ..\user;..\system\delay;..\system\sys;..\hardware\key;..\hardware\lcd1602
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c STM32F10x.s
  group hardware
    ../hardware/key/: key.c
    ../hardware/lcd1602/: lcd1602.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
