# Keil uVision project 嵌入式小车.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 嵌入式小车 +hex
  c flags: Optim=1
  c include: ..\system\delay;..\system\sys;..\system\usart;..\hardware\led;..\hardware\motor;..\hardware\timer;..\hardware\beep
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: STM32F10x.s pro.c
  group HARDWARE
    ../hardware/led/: led.c
    ../hardware/timer/: timer.c
  group SYSTEM
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
