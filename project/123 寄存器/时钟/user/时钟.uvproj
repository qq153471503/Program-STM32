# Keil uVision project 时钟.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 时钟 +hex
  c flags: Optim=1
  c include: ..\hardware\lcd1602;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user;..\hardware\KEY;..\hardware\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: STM32F10x.s
  group user
    ./: pro.c
  group hardware
    ../hardware/lcd1602/: lcd1602.c
    ../hardware/KEY/: key.c
    ../hardware/timer/: timer.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
