# Keil uVision project 外部中断实验.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 外部中断实验 +hex
  c flags: Optim=1
  c include: ..\hardware\key;..\hardware\led;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\hardware\exti
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group user
    ./: pro.c
  group hareware
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/exti/: exti.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
