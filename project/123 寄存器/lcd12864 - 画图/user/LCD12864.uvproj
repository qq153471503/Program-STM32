# Keil uVision project LCD12864.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD12864 +hex
  c flags: Optim=1
  c include: ..\hardware\lcd12864;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c STM32F10x.s
  group hardware
    ../hardware/lcd12864/: lcd12864.c pic.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
