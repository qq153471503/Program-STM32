# Keil uVision project MyProject.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\MMC_SD;..\HARDWARE\SPI;..\MALLOC;..\FATFS\exfuns;..\FATFS\src\option;..\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MMC_SD/: mmc_sd.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../readme/: readme.txt
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/: fattester.c
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/option/: cc936.c
  group MALLOC
    ../MALLOC/: malloc.c
software components: CMSIS:CORE 5.0.0
