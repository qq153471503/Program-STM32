# Keil uVision project MyProgram.uvprojx, settings and files
target MyProgram (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyProgram +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/timer/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
software components: CMSIS:CORE 5.0.0
