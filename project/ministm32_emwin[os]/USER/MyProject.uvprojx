# Keil uVision project MyProject.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\uCOS-III\UCOS-BSP;..\uCOS-III\UCOS-CONFIG;..\uCOS-III\uCOS-III;..\uCOS-III\uCOS-III\Source;..\EMWIN\DEMO
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/LCD/: ILI93XX.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group README
    ../readme/: readme.txt
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_OS_Keil.lib
  group EMWIN_DOMO
    ../EMWIN/DEMO/: DEMO.C
  group μC/OSIII-BSP
    ../uCOS-III/UCOS-BSP/: bsp.c
  group μC/OSIII-CPU
    ../uCOS-III/uC-CPU/: cpu_core.c
    ../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group μC/OSIII-LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group μC/OSIII-CORE
    ../uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group μC/OSIII-PORT
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.s
  group μC/OSIII-CONFIG
    ../uCOS-III/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 5.0.0
